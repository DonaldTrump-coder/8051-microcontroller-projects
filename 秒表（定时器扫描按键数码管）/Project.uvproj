# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c AT24C02.c AT24C02.h I2C.c I2C.h Nixie.c Nixie.h timer.c timer.h
    ./Public/: public.c public.h
    ./LCDtools/: lcd1602.c lcd1602.h
    ./Key/: Key.c Key.h
