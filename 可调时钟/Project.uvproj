# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./Public/: public.c public.h
    ./LCDtools/: lcd1602.c lcd1602.h
    ./DS1302/: DS1302.c DS1302.h
    ./Key/: Key.c Key.h
